# Keil uVision project 智能闹钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 智能闹钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 智能闹钟.c Temperature.c Clocker.c Time.c Buttons.c DisTemperature.c DisTime.c DisDate.c lcd.c common.c lcd1602.c
